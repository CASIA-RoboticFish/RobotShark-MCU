# Keil uVision project RobotShark.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: platform +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c include: ..\CORE;..\CORE\CMSIS\DSP_Lib\Includes;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Ports;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOSIII\uCOS-III\Source;..\HARDWARE\LED;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\ReactionWheel;..\HARDWARE\USART1;..\HARDWARE\USART2;..\HARDWARE\USART3;..\HARDWARE\USART6;..\HARDWARE\VALVE;..\HARDWARE\SERVO;..\HARDWARE\PUMP;..\HARDWARE\MOTOR;..\HARDWARE\VARISTOR;..\HARDWARE\ADS1115;..\HARDWARE\MS5837;..\HARDWARE\JY901;..\HARDWARE\SDIO;..\MIDDLEWARE\BuffPrintf;..\MIDDLEWARE\CPG;..\MIDDLEWARE\MATH;..\MIDDLEWARE\ServoControl;..\MIDDLEWARE\RFLink;..\MIDDLEWARE\MALLOC;..\MIDDLEWARE\FATFS\src;..\MIDDLEWARE\FATFS\src\option;..\MIDDLEWARE\FATFS\exfuns;..\MIDDLEWARE\UART6Printf;..\APPLICATION\SwimControl;..\APPLICATION\CommandAnalysis;..\APPLICATION\DiskAttach;..\APPLICATION\SensorsUpdate;..\APPLICATION\DataStorage;..\APPLICATION\DataSendBack;..\APPLICATION\DataShow;..\APPLICATION\CommandAnalysisToSlave;..\APPLICATION\PantiltControl;..\APPLICATION\TargetTracking;..\APPLICATION\DepthControl;..\APPLICATION\DistributedComunicate;..\APPLICATION\CommandAnalysisFromFriend;..\HARDWARE\TFMINI;..\APPLICATION\CollisionAvoidance;..\HARDWARE\E18Omdhon;..\APPLICATION\AutoNavigation
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/USART6/: usart6.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/IIC/: myiic1.c myiic2.c myiic3.c myiic4.c
    ../HARDWARE/SERVO/: servo_pwm.c
    ../HARDWARE/ADS1115/: ads1115.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/MS5837/: ms5837.c
    ../HARDWARE/JY901/: jy901.c
    ../HARDWARE/TFMINI/: TFmini.c
    ../HARDWARE/E18Omdhon/: E18.c
  group MIDDLEWARE
    ../MIDDLEWARE/BuffPrintf/: BuffPrintf.c MyPrintf.c
    ../MIDDLEWARE/CPG/: cpg.c
    ../MIDDLEWARE/MATH/: MyMath.c
    ../MIDDLEWARE/ServoControl/: tail_servo_control.c pectoral_servo_control.c
    ../MIDDLEWARE/RFLink/: rflink.c
    ../MIDDLEWARE/MALLOC/: malloc.c
    ../MIDDLEWARE/UART6Printf/: uart6_printf.c
  group APPLICATION
    ../APPLICATION/SwimControl/: swim_control_app.c
    ../APPLICATION/CommandAnalysis/: command_analysis_app.c
    ../APPLICATION/CommandAnalysisToSlave/: command_analysis_slave_app.c
    ../APPLICATION/SensorsUpdate/: sensors_update_app.c
    ../APPLICATION/DataStorage/: data_storage_app.c
    ../APPLICATION/DataSendBack/: data_sendback_app.c
    ../APPLICATION/DataShow/: data_show_app.c
    ../APPLICATION/PantiltControl/: pantilt_control.c
    ../APPLICATION/TargetTracking/: target_tracking_app.c
    ../APPLICATION/DepthControl/: depth_control_app.c
    ../APPLICATION/DistributedComunicate/: distributed_communicate_app.c
    ../APPLICATION/CommandAnalysisFromFriend/: command_analysis_friend_app.c
    ../APPLICATION/CollisionAvoidance/: collision_avoidance_app.c
    ../APPLICATION/AutoNavigation/: auto_navigation_app.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group DSP_LIB
    ../CORE/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
  group FATFS
    ../MIDDLEWARE/FATFS/src/: diskio.c ff.c
    ../MIDDLEWARE/FATFS/src/option/: cc936.c
    ../MIDDLEWARE/FATFS/exfuns/: exfuns.c fattester.c
